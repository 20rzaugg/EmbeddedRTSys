# Keil uVision project RTLED_lab1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RTLED_lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS:FreeRTOS 10.5.1, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.3.1
